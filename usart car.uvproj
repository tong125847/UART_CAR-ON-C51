# Keil uVision project usart car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: usart car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\普中科技单片机的蓝牙遥控小车
  group main
    ./: STARTUP.A51 main.c delay.c usart.c pwm.c beep.c bizhang.c
